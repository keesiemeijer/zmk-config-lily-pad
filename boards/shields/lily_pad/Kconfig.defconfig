## boards/shields/lily_pad/Kconfig.defconfig
```kconfig
if SHIELD_LILY_PAD

config ZMK_KEYBOARD_NAME
    default "Lily Pad"

config EC11
    default y

endif
```
